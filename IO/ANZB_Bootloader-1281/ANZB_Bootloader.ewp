# IAR project ANZB_Bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: SPEED=38400; PORT0; __ATMEGA_1281__
  ICCAVR.newCCIncludePaths: INC; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 0
  AAVR.ADefines: ENABLE_BIT_DEFINITIONS; __ATMEGA_1280__
  XLINK.XclFile: D:\S2Prog\IO\ANZB_Bootloader-1280\Link\link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: SPEED=38400; PORT0; __ATMEGA_1280__
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm1280s.xcl
  group Asm
    Asm/: assembly.s90 cstartup.s90
    Src/: flash_asm.s90
  group Common sources
    Src/: flash.c init.c main.c Misc.c serial.c Usart.c
