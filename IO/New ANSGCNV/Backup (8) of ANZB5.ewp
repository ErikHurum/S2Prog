# IAR project Backup (8) of ANZB5.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=-1
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Debug (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m128a ATmega128A
  ICCAVR.CCDefines: OS_LIBMODE_R; OS_UART=-1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
configuration Release_debug (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=0
  ICCAVR.CCOptStrategy: 1
  group embOS
    Src/: OS_Error.c rtosinit.c
  group embOSLib_3R
    Lib/: rtos3S_R.r90 rtos3S_S.r90
  group embOSLib_3SD
    Lib/: rtos3SD.r90
  group Main
    Src/: AD7715.c eeprom.c ExtInt.c init.c Main.c Misc.c RS485.c UsartInt.c UsartPro.c
