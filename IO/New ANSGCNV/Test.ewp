# IAR project Test.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 3 -v3, Max 64 Kbyte data, 128 Kbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  group Src
    Src/: AD7715.c adc.c eeprom.c ExtInt.c init.c Main.c Misc.c OS_Error.c RS485.c rtosinit.c UsartInt.c UsartPro.c
