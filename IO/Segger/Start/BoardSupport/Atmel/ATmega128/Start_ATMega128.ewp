# IAR project Start_ATMega128.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_DP
  ICCAVR.newCCIncludePaths: ..\..\..\Inc\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: OS_LIBMODE_R
configuration CSpy_Simulator (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1
  ICCAVR.CCOptStrategy: 1
  group (top)
    ./: Readme.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: ExtendTaskContext.c Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: Rtos3S_D.r90 Rtos3S_DP.r90 Rtos3S_DT.r90 Rtos3S_R.r90 Rtos3S_S.r90 Rtos3S_SP.r90 Rtos3S_XR.r90
  group Setup
    Setup/: BSP.c CSpy_ATmega128.mac OS_Error.c Rtosinit_ATmega128.c
