# IAR project TPC.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 200
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=-1
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Debug (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
configuration Release_debug (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=0
  ICCAVR.CCOptStrategy: 1
  group embOS
    Src/: OS_Error.c rtosinit.c
  group embOSLib_3R
    Lib/: rtos3S_S.r90
  group embOSLib_3SD
    Lib/: rtos3S_D.r90
  group Main
    Src/: Display.c eeprom.c ExtInt.c init.c Main.c Misc.c UsartInt.c UsartPro.c
