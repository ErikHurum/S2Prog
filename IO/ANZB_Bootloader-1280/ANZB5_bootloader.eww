<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>D:\S2Prog\IO\ANZB_Bootloader-1281\ANZB_Bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
