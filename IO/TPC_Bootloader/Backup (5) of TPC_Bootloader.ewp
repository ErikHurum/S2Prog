# IAR project Backup (5) of TPC_Bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 3 -v3, Max 64 Kbyte data, 128 Kbyte code
  ICCAVR.CCDefines: SPEED=19200; PORT0
  ICCAVR.newCCIncludePaths: INC; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: ENABLE_BIT_DEFINITIONS
  XLINK.XclFile: D:\S2Prog\IO\TPC_Bootloader\Link\link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: SPEED=9600
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  XLINK.XclFile: Link\link.xcl
  group Asm
    Asm/: assembly.s90 cstartup.s90
  group Common sources
    Src/: eeprom.c init.c main.c Misc.c serial.c Usart.c
