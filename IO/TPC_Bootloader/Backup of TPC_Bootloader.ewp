# IAR project Backup of TPC_Bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: SPEED=19200; PORT0
  ICCAVR.newCCIncludePaths: INC; ..\..\SHARED\INC\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: ENABLE_BIT_DEFINITIONS
  XLINK.XclFile: c:\S2Prog\IO\TPC_Bootloader\Link\link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  ICCAVR.CCDefines: SPEED=9600
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: Link\link.xcl
  group Asm
    Asm/: assembly.s90 cstartup.s90
  group Common sources
    Src/: eeprom.c init.c main.c Misc.c serial.c Usart.c
