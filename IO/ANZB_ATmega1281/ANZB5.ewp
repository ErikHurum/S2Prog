# IAR project ANZB5.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: OS_LIBMODE_R; OS_UART=-1; USE_16552_DRIVER_TASK=1; USE_MODBUS_PROTOCOL=0; ANZBANA_V8=1
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1281.xcl
configuration Debug (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1; USE_16552_DRIVER_TASK=1; USE_MODBUS_PROTOCOL=0; ANZBANA_V8=1
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 0
configuration Release_debug (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=0
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group embOS
    Src/: OS_Error.c rtosinit.c
  group embOSLib_3R
    ../Segger/Start/Lib/: Rtos3S_R.r90
  group embOSLib_3SD
    ../Segger/Start/Lib/: Rtos3S_D.r90
  group Init
    Lib/: low_level_init.c segment_init.c
  group Main
    Src/: AD7715.c adc.c eeprom.c ExtInt.c init.c Main.c Misc.c RS485.c UsartInt.c UsartPro.c
