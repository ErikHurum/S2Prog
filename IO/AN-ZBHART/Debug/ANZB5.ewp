# IAR project ANZB5.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x200
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: OS_LIBMODE_R; OS_UART=-1
  ICCAVR.newCCIncludePaths: INC\; ..\..\..\Shared\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
configuration Debug (AVR)
  as the first configuration, except:
  General.SCRStackSize: 0x60
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$/src/template/cfgm1280.xcl
configuration Release_debug (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=-1
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.IccLang: 2
  group embOS
    Src/: OS_Error.c rtosinit.c
  group embOSLib_3R
    ../Segger/Start/Lib/: Rtos3S_R.r90
    Lib/: rtos3S_S.r90
  group embOSLib_3SD
    ../Segger/Start/Lib/: Rtos3S_D.r90 Rtos3S_DP.r90
  group Init
    Lib/: low_level_init.c segment_init.c
  group Main
    Src/: adc.c eeprom.c hart.c hart_diag.c hart_gpio.c hart_msg.c init.c main.c Misc.c UsartInt.c UsartPro.c
