# IAR project ANZB5.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=-1; USE_MODBUS_PROTOCOL=1
  ICCAVR.newCCIncludePaths: INC\; ..\SHARED\INC\; ..\modbus\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
configuration Debug (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1; USE_MODBUS_PROTOCOL=1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
configuration Release_debug (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=0
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group embOS
    Src/: OS_Error.c rtosinit.c
  group embOSLib_3R
    Lib/: rtos3S_S.r90
  group embOSLib_3SD
    Lib/: rtos3S_D.r90
  group Init
    Lib/: low_level_init.c segment_init.c
  group Main
    Src/: eeprom.c hart.c hart_diag.c hart_gpio.c hart_msg.c init.c main.c Misc.c modbus_handler.c modbus_rtu.c UsartInt.c UsartPro.c
  group modbus
    ../modbus/: common_def.h modbus_crc.c modbus_crc.h modbus_def_user.c modbus_func_coils.c modbus_func_discrete.c modbus_func_holding.c modbus_func_input.c modbus_funcs.h modbus_rtu_request_handler.c modbus_rtu_request_handler.h modbus_util.c modbus_util.h
