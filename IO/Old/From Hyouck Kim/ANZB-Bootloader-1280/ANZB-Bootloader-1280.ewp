# IAR project ANZB-Bootloader-1280.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x96
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: __ATMEGA_1280__
  ICCAVR.newCCIncludePaths: ..\modbus\; ..\bootloader\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  AAVR.ADefines: __ATMEGA_1280__
  XLINK.XclFile: E:\VMShare\grand macron project\macron_firmwares\ANZB-Bootloader-1280\Link\link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  ICCAVR.CCDefines: NDEBUG; __ATMEGA_1280__
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: D:\S2Prog\IO\From Hyouck Kim\ANZB-Bootloader-1280\Link\link.xcl
  group asm
    ../bootloader/: flash_asm.s90
  group modbus
    ../modbus/: common_def.h modbus_crc.c modbus_crc.h modbus_def_user.c modbus_func_coils.c modbus_func_discrete.c modbus_func_holding.c modbus_func_input.c modbus_funcs.h modbus_rtu.h modbus_rtu_request_handler.c modbus_rtu_request_handler.h modbus_util.c modbus_util.h
  group src
    ../bootloader/: events.c flash.c init.c main.c modbus_handler.c timer.c
    src/: modbus_rtu.c
