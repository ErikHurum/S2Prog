# IAR project ANZB5.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=-1
  ICCAVR.newCCIncludePaths: INC\; ..\..\..\Shared\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1281.xcl
configuration Debug (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1; DEBUG
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
configuration Release_debug (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: OS_LIBMODE_S; OS_UART=0
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group embOS
    Src/: OS_Error.c rtosinit.c
    ../Segger/Start/BoardSupport/Atmel/ATmega128/Setup/: OS_Error.c
  group embOSLib_3R
    ../Segger/Start/Lib/: Rtos3S_R.r90
    Lib/: rtos3S_S.r90
  group embOSLib_3SD
    Lib/: rtos3S_D.r90
    ../Segger/Start/Lib/: Rtos3S_D.r90
  group Main
    Src/: adc.c eeprom.c hart.c hart_diag.c hart_gpio.c hart_msg.c init.c main.c Misc.c UsartInt.c UsartPro.c
