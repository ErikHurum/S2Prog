# IAR project ANZB_Bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1280 ATmega1280
  ICCAVR.CCDefines: SPEED=38400
  ICCAVR.newCCIncludePaths: INC; ..\..\SHARED\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 0
  AAVR.ADefines: ENABLE_BIT_DEFINITIONS
  XLINK.XclFile: D:\S2Prog\IO\ANZB_Bootloader\Link\link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  ICCAVR.newCCIncludePaths: INC\; ..\..\SHARED\INC\
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: Link\link.xcl
  group Asm
    Asm/: assembly.s90 cstartup.s90
  group Common sources
    Src/: init.c main.c Misc.c serial.c Usart.c
