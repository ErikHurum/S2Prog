# IAR project BootTXU.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: OS_LIBMODE_DT; CPU_S3C2410; OS_UART=-1; OS_SEGGER; S2TXUBOOTLOADER
  ICCARM.CCIncludePath2: INC\; ..\Shared\INC\; ..\SHARED\SRC\; GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\
  AARM.ADefines: __ARM_LIBRARY__; _ECPLUSPLUS
  AARM.AUserIncludes: INC\
  AARM.AExtraOptionsV2: -j
  XLINK.XclFile: F:\S2Prog\TXU\LINK\TXUBootloader_lnk.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8f.h
  ICCARM.CCDefines: OS_LIBMODE_R; CPU_S3C2410; OS_UART=1; TXU_TARGET; __ARM_LIBRARY__; TXU_RELEASE; ANBOOTLOADER; WATCHDOG=1
  ICCARM.CCIncludePath2: GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\; ..\SHARED\SRC\; ..\SHARED\LZO\minilzo.206\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: LINK\TXUBootloader_lnk.xcl
configuration TargetDebug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8f.h
  ICCARM.CCDefines: OS_LIBMODE_DP; OS_RAMVECT=0; CPU_S3C2410; OS_UART=1; ANBOOTLOADER; __ARM_LIBRARY__
  ICCARM.CCIncludePath2: GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\; ..\SHARED\SRC\; ..\SHARED\LZO\MINILZO.108\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: LINK\StartTXU_lnk.xcl
  group Bitmaps
    ../Shared/BMPfiles/: Ariston_logo2.c
    ../Shared/IconsAndBMP/: scanjet-logo.c
  group CStartup
    CStartup/: Clock.c cstartup.s79 low_level_init.c swi_handler.s79 time.c
  group DataCompression
    ../Shared/LZO/minilzo.206/: minilzo.c
  group embOS
    src/: RTOSVECT.ASM UserIRQ.c
  group ETC
    ETC/: simS3c2410.mac TXU_S3C2410_Reset.cmm TXU_S3C2410_Start.cmm
  group GUI
    TargetDebug/Lib/: GUI_Lib.r79
    Config/: GUI_TOUCH_DriverAnalog.c GUI_X_embOS.c guitask.c LCD_Lib.cpp
  group Lib
    Lib/: osA4LFDP.r79 osA4LFR.r79 osA4LNDP.r79
  group Shared
    ../Shared/Src/: Anpro10.cpp ANPRO10UnitInfo.cpp TSNAsyncReceiver.cpp TSNAsyncsender.cpp TSNMessageQ.cpp TSNString.cpp TSNUart.cpp TSNUtilities.cpp
  group Target
    src/: 2410Clib.cpp 2410SLib.s BootWindowSystem.cpp mmu.c mx29LV160TB.cpp OS_Error.c SC2410RTC.cpp SC2410Uart.cpp ST16554Uart.cpp StartTXU.cpp TXU_ RTOSInit.c Txu_cstartup.s Txu_HW_Init.cpp
