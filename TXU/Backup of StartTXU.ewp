# IAR project Backup of StartTXU.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OS_LIBMODE_DT; CPU_S3C2410; OS_UART=1; OS_SEGGER
  ICCARM.CCIncludePath2: INC\; GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: INC\; $EW_DIR$\INC\
  XLINK.XclFile: F:\S2Prog\TXU\LINK\StartTXU_lnk.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OS_LIBMODE_R; CPU_S3C2410; OS_UART=1; TXU_TARGET; __ARM_LIBRARY__; TXU_RELEASE; S2TXU
  ICCARM.CCIncludePath2: GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\; ..\SHARED\SRC\
  AARM.ADefines: __ARM_LIBRARY__; _ECPLUSPLUS
  AARM.AExtraOptionsV2: -j
configuration TargetDebug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8f.h
  General.OGChipSelectEditMenu: S3C2410A Samsung S3C2410A
  ICCARM.CCDefines: OS_LIBMODE_SP; CPU_S3C2410; OS_RAMVECT=0; OS_UART=-1; S2TXU; USE_LZO=1; __ARM_LIBRARY__; WATCHDOG=1; NETWORK=1
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\; ..\SHARED\SRC\; ..\SHARED\LZO\minilzo.210\; lwip-1.4.1\src\include; lwip-1.4.1\src\include\ipv4\; lwip-1.4.1\src; ..\SHARED\Database\; src
  AARM.ADefines: __ARM_LIBRARY__; _ECPLUSPLUS
  AARM.AUserIncludes: INC\
  AARM.AExtraOptionsV2: -j
  XLINK.XclFile: LINK\StartTXU_lnk.xcl
  group BitMaps
    ../Shared/BMPfiles/: Ariston_logo2.c ButtonBallast.c ButtonCargo.c ButtonCargoLinePress.c ButtonGasSampling.c ButtonHighLevel.c ButtonService.c ButtonSystem.c ButtonTankPress.c ButtonTankwash.c ButtonTemperature.c ButtonVapourReturnPress.c ButtonVoidSpace.c ButtonWaterIngress.c LTank.c LTankOverfill.c LTankWaterInOil.c scanjet-logo.c
    src/: ButtonTankwash.c
  group CStartup
    CStartup/: Clock.c localtim.c low_level_init.c time.c
  group DataCompression
    ../Shared/LZO/minilzo.206/: minilzo.c
    ../Shared/LZO/minilzo.209/: minilzo.c
    ../Shared/LZO/minilzo.210/: minilzo.c
  group DLib
    $EW_DIR$/arm/config/template/project/dlib/: close.c remove.c write.c
    DLIB/: MtxWrapper.c
  group embOS
    Config/: GUI_X_embOS.c
    src/: RTOSVECT.ASM UserIRQ.c
  group ETC
    ETC/: simS3c2410.mac TXU_S3C2410_Reset.cmm TXU_S3C2410_Start.cmm
  group GUI
    Config/: GUI_TOUCH_DriverAnalog.c
  group IOModules
    IOModules/: ANZB5Bin.c
  group Lib
    ../../Segger/embOS/Start/Lib/: os4tpainl8r.r79 os4tpannl8r.r79
    Lib/: os4tpainl8s.r79 osA4LFDP.r79 osA4LNDP.r79
    ../Segger/embOS/Start/Lib/: os4tpainl8sp.r79
    ../../Segger/embOS-ARM9/Start/Lib/: osA4LDP.r79
  group Network/api
    lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Network/app
    lwip-1.4.1/src/app/: circ_buffer.c lwip_lib.c sg_timer.c shell.c tftp_server.c
  group Network/Arch
    lwip-1.4.1/src/arch/: sys_arch.c
  group Network/Core
    lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Network/Core/ipv4
    lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Network/Core/ipv6
    lwip-1.4.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group Network/Core/snmp
    lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group Network/Netif
    lwip-1.4.1/src/netif/: cs8900if.c cs8900if_no_optimize.c etharp.c ethernetif.c slipif.c
  group Shared
    ../Shared/Src/: AI_AC_Sensor.cpp AIAirPurgePressSensor.cpp AIAtmPressSensor_mA.cpp AIAtmPressSensor_mV.cpp AICoilInSensor.cpp AIDiffPressSensor_mA.cpp AIFloatSensor_mA.cpp AIFuseSensor.cpp AIInclinometer.cpp AIInclinometer_mA.cpp AIInclinometerN2.cpp AILevelSwitch_mA.cpp AILevelSwitchOptical_mA.cpp AILevelSwitchSensor_mV.cpp AILevelSwitchVega.cpp AILNGFloat.cpp AIMetriTapeSensor.cpp AIModbusDiffPressSensor_mA.cpp AIModbusPressSensor_mA.cpp AIPressSensor.cpp AIPressSensor_mA.cpp AIPressSensor_mV.cpp AIRadarSensor.cpp AIRadarSensor_mA.cpp AIRadarSensorHart.cpp AITempSensor.cpp AITempSensor_AD590.cpp AITempSensor_mA.cpp AITempSensor_Pt100.cpp AITempSensor_Pt1000.cpp AIVoltageSensor.cpp AIWashTrackSensor.cpp AIWaterIngressSensor.cpp AIWIngressTempSensor.cpp AlarmAC_Voltage.Cpp AlarmAirPurgeSensorFailure.cpp AlarmAtmOutOfRange.Cpp AlarmBasic.cpp AlarmCriticalComFailure.cpp AlarmFuse.Cpp AlarmHartSensorComError.cpp AlarmHartSensorOpenLoop.cpp AlarmHartSensorShortCircuit.cpp AlarmHighBotTemp.Cpp AlarmHighIGP.Cpp AlarmHighLevel.Cpp AlarmHighLinePressure.Cpp AlarmHighPressure.Cpp AlarmHighPressVac.Cpp AlarmHighTemp.Cpp AlarmHighVapRet.Cpp AlarmHighVoltage.Cpp AlarmHiHiLinePressure.Cpp AlarmInclinometerFailure.cpp AlarmIntHighPressure1.Cpp AlarmIntHighPressure2.cpp AlarmIntLowPressure1.Cpp AlarmIntLowPressure2.cpp AlarmIOComFailure.cpp AlarmLevelChange.Cpp AlarmLevelDifference.Cpp AlarmLevelSwitch.Cpp AlarmLevelSwitchDead.Cpp AlarmLevelSwitchFailure.Cpp AlarmLevelSwitchLight.Cpp AlarmLevelSwitchTest.Cpp AlarmLoLoLevel.Cpp AlarmLowBotTemp.Cpp AlarmLowIGP.Cpp AlarmLowLevel.Cpp AlarmLowLinePressure.Cpp AlarmLowPressure.Cpp AlarmLowPressVac.Cpp AlarmLowTemp.Cpp AlarmLowVapRet.Cpp AlarmLowVoltage.Cpp AlarmMainWaterIngress.Cpp AlarmmAmpOpenLoop.cpp AlarmmAmpShortCircuit.cpp AlarmModbusComFailure.cpp AlarmModbusInCoil.cpp AlarmOverfill.Cpp AlarmPreWaterIngress.cpp AlarmSCComFailure.cpp AlarmSensorConCalError.cpp AlarmSensorConvError.cpp AlarmTXUComFailure.cpp AlarmVoidSpace.Cpp AlarmWaterDetect.Cpp AnalogInput.cpp ANCriticalSection.cpp ANPRO1.cpp Anpro10.cpp ANPRO10Object.cpp Anpro3object.cpp AnsiString.cpp API.Cpp AsyncsenderNetwork.cpp CargoTypeObject.cpp CTOUser.cpp CtrlAlarmRelay.cpp CtrlBuzzer.cpp CtrlHorn.cpp CtrlLamp.cpp CtrlLight.cpp DigitalInput.cpp FastFourier.cpp InputResponseTimer.cpp IOSimulator.cpp IOUnit.cpp IOUnitZB485.cpp IOUnitZBAna.cpp IOUnitZBHart.cpp LibrarianMenuDefinitions.cpp LibrarianReadData.cpp LibrarianShared.cpp LibrarianWriteData.cpp LoadReport.cpp ModbusCoil.cpp ModbusCoilHistory.cpp ModbusCoilIn.cpp ModbusCoilOut.cpp ModbusMultiple.cpp ModbusObject.cpp ModbusPro.cpp ModbusRegBitIn.cpp ModbusRegBitOut.cpp ModbusRegister.cpp ModbusRegisterHistory.cpp ModbusRegisterIn.cpp ModbusRegisterOut.cpp ModbusUnit.cpp ModbusWago473RegisterIn.cpp ModbusWago479RegisterIn.cpp ModbusWago482RegisterIn.cpp ModbusWago485RegisterIn.cpp ModbusWago487RegisterIn.cpp PrintReport.cpp PROAtmReference.cpp PROBallastTank.cpp PROCargoTank.cpp PROControl.cpp PRODraft.cpp PRODraftSystem.cpp PRogramObject.cpp PRogramObjectBase.cpp PROInclinometer.cpp PROIOComponent.cpp PROLevelSwitch.cpp PROLinePressure.cpp PROLinkedList.cpp PRONode.cpp PROPrinter.cpp PROProjectInfo.cpp PROSafeLinkedList.cpp PROServiceTank.cpp PROSystemData.Cpp PROTank.cpp PROTankPressure.cpp PROTankSum.cpp PROTanksystemUnit.cpp PROTankWashingMachine.cpp PROTemperature.cpp PROUser.cpp PROVoidSpace.cpp PROWaterHeater.cpp PROWaterIngress.cpp PROXRefObject.cpp ReadConfig.cpp SaabProtocol.cpp SCADCard.cpp SCWaterIngress.cpp SignalConverter.cpp TankWashingAPI.cpp TankWashingCalcParameters.cpp TankWashingCleaningMedia.cpp TankWashingMachine.cpp TPCAlarmWindow.cpp TPCWindow.cpp TPCWindow140.cpp TPCWindow196.cpp TPCWindow350.cpp TPCxObject.cpp TSNAsyncReceiver.cpp TSNAsyncsender.cpp TSNConfigInfo.cpp TSNConfigString.cpp TSNConfigUtilities.cpp TSNGlobalVariables.cpp TSNLanguage.cpp TSNLanguageDutch.cpp TSNLanguageEnglish.cpp TSNLanguageFrench.cpp TSNLanguageGerman.cpp TSNLanguageNorwegian.cpp TSNMessageQ.cpp TSNSaveSettings.cpp TsnTable.Cpp TSNTable1Degree.Cpp TSNTable2Degree.Cpp TSNTableCenterOfFlotation.Cpp TSNTableLevelCorrection.cpp TSNTimer.cpp TSNUart.cpp TSNUtilities.cpp
    src/: TDUGlobalVariables.cpp
  group Target
    src/: 2410Clib.cpp 2410SLib.s exception_handler.c exception_helper.s mmu.c mx29LV160TB.cpp OS_Error.c SC2410RTC.cpp SC2410Uart.cpp ST16554Uart.cpp TXU_ RTOSInit.c Txu_cstartup.s Txu_HW_Init.cpp
    TargetDebug/Lib/: GUI_Lib.r79
  group TXU
    src/: anpro_net.cpp anpro_net_util.cpp anpro_tcp_client.cpp anpro_tcp_server.cpp anpro_udp.cpp CloseWindowTimer.cpp ConfigApp.cpp FlashFileSystem.cpp FlashLocalSettings.cpp Network.cpp StartTXU.cpp TSNTasks.cpp WindowsSystem.cpp
    Config/: LCD_Lib.cpp
  group TXU/GUI
    src/: TDUAlarmWindow.cpp TDUAppSetupBallast.cpp TDUAppSetupCargo.cpp TDUAppSetupService.cpp TDUAppSetupTankFarm.cpp TDUAppSetupTankPress.cpp TDUAppSetupTemp.cpp TDUAppSetupVoidSpace.cpp TDUAppWinSetup.cpp TDUBallastWin.cpp TDUBasicWin.cpp TDUButWin.cpp TDUCaldataWin.cpp TDUCalibrateScreen.cpp TDUCargoWin.cpp TDUConfigLoginWin.cpp TDUConfigWarningsWin.cpp TDUConfigWin.cpp TDUGroupWin.cpp TDUKeyBoard.cpp TDULevelSwitchWin.cpp TDULinePressWin.cpp TDUMainWin.cpp TDUMessageBox.cpp TDUMessageBoxCancel.cpp TDUMessageBoxList.cpp TDUMultipageTankDetails.cpp TDUNotConfiguredWin.cpp TDUPresentWin.cpp TDUPrinterSetupWin.cpp TDUServiceWin.cpp TDUSysSetupWin.cpp TDUSystemWin.cpp TDUSysWin1.cpp TDUSysWin2.cpp TDUSysWin3.cpp TDUSysWin4.cpp TDUSysWin5.cpp TDUTankCleaningDetailsWin.cpp TDUTankCleaningWin.cpp TDUTankFarmWin.cpp TDUTankPressWin.cpp TDUTempGraphWin.cpp TDUTempWin.cpp TDUUserManual.cpp TDUUtilities.cpp TDUVoidSpaceWin.cpp TDUWaterIngressWin.cpp
