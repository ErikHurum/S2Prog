# IAR project FlashTXU.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\; INC\; ..\Shared\INC\; GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\
  ICCARM.CCDefines: OS_LIBMODE_DT; CPU_S3C2410; OS_UART=-1; OS_SEGGER; S2BOOTLOADER
  XLINK.XclFile: F:\S2Prog\TXU\LINK\TXUBootloader_lnk.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\; GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\
  ICCARM.CCDefines: OS_LIBMODE_R; CPU_S3C2410; OS_UART=0; TXU_TARGET; __ARM_LIBRARY__; TXU_RELEASE
  AARM.ADefines: __ARM_LIBRARY__; _ECPLUSPLUS
  AARM.AExtraOptions: -j
configuration TargetDebug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\; GUI\CORE\; GUI\WM\; GUI\WIDGET\; CONFIG\; INC\; ..\SHARED\INC\; ..\SHARED\SRC\
  ICCARM.CCDefines: OS_LIBMODE_DT; CPU_S3C2410; OS_UART=0; S2TXUBOOTLOADER; S2TXUFLASH; __ARM_LIBRARY__
  AARM.ADefines: __ARM_LIBRARY__; _ECPLUSPLUS
  AARM.AExtraOptions: -j
  XLINK.XclFile: F:\S2Prog\TXU\LINK\StartTXU_lnk.xcl
  group CStartup
    CStartup/: clock.c localtim.c low_level_init.c time.c
  group embOS
    src/: UserIRQ.c
  group ETC
    ETC/: simS3c2410.mac TXU_S3C2410_Reset.cmm TXU_S3C2410_Start.cmm
    Release/Exe/: StartTXUBin.c
  group Lib
    Lib/: osA9LLDT.r79 osA9LLR.r79
  group Shared
    ../Shared/Src/: TSNString.cpp TSNUart.cpp TSNUtilities.cpp
  group Target
    src/: 2410lib.c 2410slib.s79 mmu.c mx29LV160TB.cpp OS_Error.c SC2410Uart.cpp ST16554Uart.cpp StartTXU.cpp TXU_ RTOSInit.c Txu_Bootloader_startup.s79 Txu_HW_Init.c
