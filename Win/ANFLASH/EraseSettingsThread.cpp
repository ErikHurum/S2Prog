#include "TXUFlashProgMain.h"
#include "TSNVersion.h"
#include <stdlib.h>
#pragma hdrstop

#include "EraseSettingsThread.h"
#pragma package(smart_init)
//---------------------------------------------------------------------------

//   Important: Methods and properties of objects in VCL can only be
//   used in a method called using Synchronize, for example:
//
//      Synchronize(&UpdateCaption);
//
//   where UpdateCaption could look like:
//
//      void __fastcall EraseSettingsThread::UpdateCaption()
//      {
//        Form1->Caption = "Updated in a thread";
//      }
//---------------------------------------------------------------------------

__fastcall EraseSettingsThread::EraseSettingsThread(bool CreateSuspended,TTXUFlashProg *MyOwner,U8 EraseCmd, AnsiString Message)
	: TThread(CreateSuspended)
{
	MyForm 	  		= MyOwner;
	Priority  		= tpHigher;
	Size	  		= 0;
	PCnt 	  		= 0;
	PosCnt 	  		= 0;
	EraseCommand 	= EraseCmd;
	Msg				= Message;
}
//---------------------------------------------------------------------------
void __fastcall EraseSettingsThread::Execute()
{
	//---- Place thread code here ----
	MyForm->CanReceive = true;
	SendEraseSettings();
	MyForm->CanReceive = false;
}
//---------------------------------------------------------------------------
 void __fastcall EraseSettingsThread::SendEraseSettings(void)
{
	U8 *TempRxBuf = new U8[2*MAX_ANPRO10_SIZE+P_START_SIZE+sizeof(ANPRO10_PacketTail)+P_COMMAND_SIZE];
	Synchronize(InitDownload);
	try
	{
		ANPRO10_FLASH_ERASE Command;
		Command.CommandNo	= CMD_ERASE_FLASH;
		Command.EraseCommand= EraseCommand;
		Command.ndb 		= 1;
		DownloadAck 		= FLASH_PROGRAM_TIMEOUT;

		for(int RetryCnt=0; DownloadAck==FLASH_PROGRAM_TIMEOUT && RetryCnt < 3; RetryCnt++){
			ANPRO10_SendCommand(MyForm->WinUartPtr,(U8*)&Command,MyForm->RxAddress,MyForm->RxTypeId);
			Sleep(1000);
			Synchronize(UpdateDownload);
			int RetryCnt2=0;
			do{
				ANPRO10_Receive(MyForm->WinUartPtr,500,TempRxBuf);
			}while((RetryCnt2++ < 500) && DownloadAck==FLASH_PROGRAM_TIMEOUT);
		}
		Synchronize(FinalizeDownload);
	}
  __finally
  {
	Synchronize(Final);
  }
  delete TempRxBuf;
}
//---------------------------------------------------------------------------
void __fastcall EraseSettingsThread::InitDownload(void)
{
	Save_Cursor = Screen->Cursor;
	Screen->Cursor = crHourGlass;    // Show hourglass cursor
	MyForm->PacketCount->Caption 		= 0;
	MyForm->CompressionLabel->Caption 	= 0;
	MyForm->DownloadProgressBar->Min 	= 0;
	MyForm->DownloadProgressBar->Max 	= 100;
	MyForm->CurrentOperation->Caption 	= "Erasing "+Msg;;
	MyForm->CurrentOperation->Font->Color = clWindowText;

}
//---------------------------------------------------------------------------

void __fastcall EraseSettingsThread::UpdateDownload(void)
{
	  MyForm->DownloadProgressBar->Position = 0;
	  MyForm->PacketCount->Caption = ++PCnt;
	  MyForm->CompressionLabel->Caption = 0;
	  MyForm->CurrentOperation->Caption = "Waiting for erase "+Msg;
}
void __fastcall EraseSettingsThread::FinalizeDownload(void)
{
	switch(DownloadAck){
	case FLASH_NO_ERROR:
		  MyForm->CurrentOperation->Caption = Msg+" erased successfully";
		  MyForm->CurrentOperation->Font->Color   = clGreen;
		  break;
	case FLASH_ERASE_FAILURE:
		  MyForm->CurrentOperation->Caption = Msg+" Erase Failure";
		  MyForm->CurrentOperation->Font->Color   = clRed;
		  break;
	case FLASH_PROGRAM_TIMEOUT:
		  MyForm->CurrentOperation->Caption = Msg+" Erase Timeout";
		  MyForm->CurrentOperation->Font->Color   = clRed;
		  break;
	}
	MyForm->Show();   // show a splash screen contain ProgressBar control
	MyForm->Update(); // force display of form
}
//---------------------------------------------------------------------------

void __fastcall EraseSettingsThread::Final(void)
{
	Screen->Cursor = Save_Cursor; // always restore the cursor
}
//---------------------------------------------------------------------------
