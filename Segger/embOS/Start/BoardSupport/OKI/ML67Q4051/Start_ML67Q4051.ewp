# IAR project Start_ML67Q4051.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: ML67Q4050 Oki ML67Q4050
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: TARGET_JTAG
  XLINK.XclFile: Setup\ML67Q4051_RAM.xcl
configuration Debug_FLASH (ARM)
  as the first configuration, except:
  XLINK.XclFile: Setup\ML67Q4051_FLASH.xcl
configuration Release_FLASH (ARM)
  as the first configuration, except:
  XLINK.XclFile: Setup\ML67Q4051_FLASH.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c ML674050_60_CStartup_V4.s79 OS_Error.c RTOSINIT_ML67Q4051.c
