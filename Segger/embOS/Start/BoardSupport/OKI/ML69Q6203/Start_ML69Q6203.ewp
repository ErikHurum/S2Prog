# IAR project Start_ML69Q6203.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: ML69Q6203 OKI ML69Q6203
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\ML69Q6203_RAM.xcl
  group (top)
    ./: Readme.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os5tptnnl8dp.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c ML69Q6203_CStartup_V4.s79 OS_Error.c RTOSINIT_ML69Q6203.c
