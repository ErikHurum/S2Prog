<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_ML69Q6203.ewp</path>
  </project>
  <batchBuild/>
</workspace>


