# IAR project Start_ADuC702x.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: ADuC7026 AnalogDevices ADuC7026
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\ADuC702x_RAM.xcl
configuration Debug_FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ADuC7020 AnalogDevices ADuC7020
  XLINK.XclFile: Setup\ADuC702x_FLASH.xcl
configuration Release_FLASH (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ADuC7020 AnalogDevices ADuC7020
  XLINK.XclFile: Setup\ADuC702x_FLASH.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c OS_Error.c RTOSINIT_ADuC702x.c Startup.s79
