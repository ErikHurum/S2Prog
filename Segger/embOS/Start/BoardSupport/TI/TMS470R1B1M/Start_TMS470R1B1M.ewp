# IAR project Start_TMS470R1B1M.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnb8n.h
  General.OGChipSelectEditMenu: TMS470R1B1M TexasInstruments TMS470R1B1M
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: INC\
  XLINK.XclFile: Setup\TMS470R1B1M_RAM.xcl
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: Setup\TMS470R1B1M_FLASH.xcl
configuration Release_FLASH (ARM)
  as the first configuration, except:
  XLINK.XclFile: Setup\TMS470R1B1M_FLASH.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnb8dp.r79 os4tptnnb8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_TMS470R1B1M.c Startup_TMS470R1B1M.s79
