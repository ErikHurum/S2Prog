# IAR project Start_LH79520.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: LH79520 Sharp LH79520
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\LH79520.xcl
configuration Release_ROM (ARM)
  as the first configuration, except:
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_LH79520.c Startup.s79
