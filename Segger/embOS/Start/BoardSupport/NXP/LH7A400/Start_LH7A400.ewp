# IAR project Start_LH7A400.ewp, settings and files
configuration Release_ROM (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: LH7A400 Sharp LH7A400
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: TARGET_ROM
  XLINK.XclFile: Setup\LH7A400_ROM.xcl
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1
  AARM.ADefines: TARGET_JTAG
  XLINK.XclFile: Setup\LH7A400_SDRAM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c LH7A400_MMU.s79 LH7A400_RAM.mac OS_Error.c RTOSINIT_LH7A400.c Startup.s79
