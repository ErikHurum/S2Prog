# IAR project Start_LPC3180.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: LPC3180 Philips LPC3180
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\LPC3180_iRAM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: ExtendTaskContext.c ExtendTaskContextVFP.c Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os5tpannl8dp.r79 os5tptnnl8dp.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_LPC3180.c Startup.s79
