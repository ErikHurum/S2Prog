# IAR project STR912_JumpTable.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: STR912 ST STR912
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\STR912_FLASH.xcl
  group Setup
    Setup/: STR912_JumpVect.s79
