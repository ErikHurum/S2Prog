<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_STR912.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\STR912_JumpTable.ewp</path>
  </project>
  <batchBuild/>
</workspace>


