# IAR project Start_AT91M55800.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: AT91M55800 Atmel AT91M55800
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: TARGET_JTAG
  XLINK.XclFile: Setup\AT91M55800_RAM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: AT91M55800_CStartup_V4.s79 BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91M55800.c
