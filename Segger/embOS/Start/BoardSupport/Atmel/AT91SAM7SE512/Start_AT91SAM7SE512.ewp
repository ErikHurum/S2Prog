# IAR project Start_AT91SAM7SE512.ewp, settings and files
configuration Debug_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: AT91SAM7SE512 Atmel AT91SAM7SE512
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: INC\
  XLINK.XclFile: Setup\AT91SAM7SE512_FLASH.xcl
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: Setup\AT91SAM7SE512_RAM.xcl
configuration Release_FLASH (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91SAM7SE512.c Startup.s79
