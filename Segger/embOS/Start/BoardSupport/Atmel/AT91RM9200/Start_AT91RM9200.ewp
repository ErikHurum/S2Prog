# IAR project Start_AT91RM9200.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: AT91RM9200EK Atmel AT91RM9200EK
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\AT91RM9200_iRAM.xcl
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: TARGET_JTAG
  XLINK.XclFile: Setup\AT91RM9200_FLASH.xcl
configuration Release_FLASH (ARM)
  as the first configuration, except:
  XLINK.XclFile: Setup\AT91RM9200_FLASH.xcl
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: Setup\AT91RM9200_SDRAM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91RM9200.c Startup.s79
