# IAR project Start_AT91SAM9263.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: AT91SAM9263 Atmel AT91SAM9263
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: INC\
  XLINK.XclFile: Setup\AT91SAM9263_iRAM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os5tptnnl8dp.r79 os5tptnnl8r.r79
  group Setup
    Setup/: AT91SAM9261_iRAM.mac AT91SAM9261_iRAM.xcl BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91SAM9263.c Startup.s79
