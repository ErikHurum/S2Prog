# IAR project Start_AT91M40xxx.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  General.OGChipSelectEditMenu: AT91EB40A Atmel AT91EB40A
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: TARGET_JTAG
  XLINK.XclFile: Setup\AT91M40xxx_RAM.xcl
configuration Release_ROM (ARM)
  as the first configuration, except:
  AARM.ADefines: TARGET_ROM
  XLINK.XclFile: Setup\AT91M40xxx_ROM.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Lib
    ../../../Lib/: os4tptnnl8dp.r79 os4tptnnl8r.r79
  group Setup
    Setup/: AT91M40xxx_CStartup_V4.s79 BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91M40xxx.c
