# IAR project Start_AT91SAM9261.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: AT91SAM9261EK Atmel AT91SAM9261EK
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: INC\
  XLINK.XclFile: Setup\AT91SAM9261_iRAM.xcl
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
configuration Release_FLASH (ARM)
  as the first configuration, except:
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SDRAM_TARGET=1
  XLINK.XclFile: Setup\AT91SAM9261_SDRAM.xcl
configuration Release_SDRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SDRAM_TARGET=1
  XLINK.XclFile: Setup\AT91SAM9261_SDRAM_DF.xcl
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_LEDBlink.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_2Tasks.c
  group Flashloader
    Flashloader/: Flashloader_AT91SAM9261.d79
  group Lib
    ../../../Lib/: os5tptnnl8dp.r79 os5tptnnl8r.r79
  group Setup
    Setup/: BootLoaderDF_AT91SAM9261_2MB.c BSP.c JLINKDCC_Process.c OS_Error.c RTOSINIT_AT91SAM9261.c Startup.s79
