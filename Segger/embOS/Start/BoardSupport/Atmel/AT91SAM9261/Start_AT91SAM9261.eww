<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_AT91SAM9261.ewp</path>
  </project>
</workspace>


