# IAR project Start_IAR_Simulator.ewp, settings and files
configuration Simulator_DEBUG (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptnnl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: DEBUG=1
  ICCARM.CCIncludePath2: Inc\; ..\..\Inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Setup\IAR_Simulator.xcl
configuration Simulator_RELEASE (ARM)
  as the first configuration, except:
  group (top)
    ./: ReadMe.txt
  group Application
    Application/: Start_2Tasks.c
  group Application/Excluded
    Application/: Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c
  group Lib
    ../../Lib/: os5tptnnl8dp.r79 os5tptnnl8r.r79
  group Setup
    Setup/: OS_Error.c RTOSINIT_Simulator.c Startup.s79
