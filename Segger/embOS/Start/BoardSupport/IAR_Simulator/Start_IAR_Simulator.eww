<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start_IAR_Simulator.ewp</path>
  </project>
  <batchBuild/>
</workspace>


